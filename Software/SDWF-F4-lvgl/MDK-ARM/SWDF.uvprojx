# Keil uVision project SWDF.uvprojx, settings and files
target SWDF (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SWDF +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --diag_suppress=188,546,68,111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Src;..\Src\lvgl;..\Src\lvgl\src;..\Src\lvgl\examples\porting
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Src
    ../Src/: drv_lcd.c bsp_systick.c system_start.c bsp_gpio.c system.h drv_lcdfont.h
  group lvgl
    ../Src/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Src/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Src/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Src/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Src/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Src/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Src/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Src/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Src/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Src/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Src/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Src/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Src/lvgl/src/extra/: lv_extra.c
    ../Src/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Src/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Src/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Src/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Src/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Src/lvgl/src/extra/widgets/led/: lv_led.c
    ../Src/lvgl/src/extra/widgets/list/: lv_list.c
    ../Src/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Src/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Src/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Src/lvgl/src/extra/widgets/span/: lv_span.c
    ../Src/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Src/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Src/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Src/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Src/lvgl/src/extra/widgets/win/: lv_win.c
    ../Src/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_port
    ../Src/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../Src/lvgl/: lv_conf.h lvgl.h
software components: CMSIS:CORE 4.3.0
